# Repository test-gh-syncer2/Soldered-Dasduino-CONNECT-hardware-design

## KiCad design CAD/V1.1.1/Dasduino_CONNECT.kicad_pcb

Parts:
C1, C2: 0.1uF; 0603C
C3, C5, C7, C8: 2.2uF; 0603C
C4, C9: 100nF; 0603C
C6: 270pF; 0603C
D1: blue; 0402LED
D2: orange; 0402LED
D3: purple; 0402LED
D4: WS2812B-2020
D5: red; 0402LED
D7: BAT20J; SOD-323
F1: 1206FUSE-500mA; 1206FUSE
FD1: FIDUCIAL; FIDUCIAL_23
H1, H2: HOLE_3.2mm
JP1: SMD-JUMPER-CONNECTED_TRACE_SLODERMASK
K1: easyC-SMD; easyC-connector
K2: U262-161N-4BVC11
K3: JST-2pin-SMD
K4, K5: HEADER_MALE_15X1
Q1: PMOS-SOT-23-3; SOT-23-3
Q2, Q3: NPN-SOT-23-3; SOT-23-3
R1, R2, R5: 1k; 0603R
R3, R4, R6, R12: 2k2; 0402R
R7, R8: 5.1k; 0603R
R9, R10, R16, R17, R18, R19, R20, R21: 10k; 0603R
R11: 3k; 0603R
R14: 100k; 0603R
R15: 2.5k; 0603R
SW1, SW2: YTSA007A0151803B
U1: CH340C; SOP-16
U2: TPS7A2633DRVR
U3: TP4056M; TP4056M-MSOP8
U4: ESP8266(ESP12-F); ESP 8266(ESP12-F)

Connections:
+3V3: C5.2, C9.2, JP1.1, K1.3 (3V3), K4.4, K5.4, K5.5, K5.6, K5.7, R10.2, R16.2, R17.2, R18.2, U2.1 (OUT), U4.8 (VCC)
ADC: K4.8, R9.1, R15.2, U4.2 (ADC)
ADC_E: K4.7, R9.2
CH_PD: K4.9, R17.1, U4.3 (EN)
D+: K2.A6 (DP1), K2.B6 (DP2), U1.5 (UD+)
D-: K2.A7 (DN1), K2.B7 (DN2), U1.6 (UD-)
DTR: Q3.2 (E), R20.1, U1.13 (DTR#)
GND: C1.1, C2.2, C3.1, C4.2, C5.1, C6.1, C7.1, C8.1, C9.1, D3.2 (K), D4.2 (GND), K1.4 (GND), K1.5 (SHIELD), K2.A1 (GND), K2.A12 (GND), K2.B1 (GND), K2.B12 (GND), K2.SH (SHIELD), K3.2 (-), K4.3, K5.1, K5.8, K5.9, K5.10, K5.13, R7.2, R8.2, R11.2, R14.1, R15.1, R19.1, SW1.1, SW2.2, U1.1 (GND), U2.5 (GND), U3.1 (TEMP), U3.3 (GND), U4.9 (GND)
IO0: K5.2, Q3.3 (C), R18.1, SW1.2, U4.12 (GPIO0)
IO2: K5.3, R5.1, R16.1, U4.11 (GPIO2)
IO16: K4.6, U4.4 (GPIO16)
unnamed: C2.1, U1.4 (V3)
unnamed: D1.1 (A), R3.1
unnamed: D2.1 (A), R4.1
unnamed: D3.1 (A), R6.2
unnamed: D4.3 (DI), R5.2
unnamed: D5.2 (K), R12.2
unnamed: F1.2, K2.A4 (VBUS), K2.A9 (VBUS), K2.B4 (VBUS), K2.B9 (VBUS)
unnamed: K2.A5 (CC1), R8.1
unnamed: K2.B5 (CC2), R7.1
unnamed: Q2.1 (B), R20.2
unnamed: Q3.1 (B), R21.2
unnamed: R1.1, U1.2 (TXD)
unnamed: R2.1, U1.3 (RXD)
unnamed: JP1.2, R6.1
unnamed: R11.1, U3.2 (PROG)
unnamed: R12.1, U3.7 (~CHRG)
RESET: C6.2, K4.5, Q2.3 (C), R10.1, SW2.1, U4.1 (RST)
RTS: Q2.2 (E), R21.1, U1.14 (RTS#)
RXD0: D2.2 (K), K4.15, R1.2, U4.15 (RXD)
SCL: K1.1 (SCL), K5.14, U4.14 (GPIO5)
SDA: K1.2 (SDA), K5.15, U4.13 (GPIO4)
SPI_CS: K4.10, R19.2, U4.10 (GPIO15)
SPI_MISO: K4.13, U4.6 (GPIO12)
SPI_MOSI: K4.12, U4.7 (GPIO13)
SPI_SCK: K4.11, U4.5 (GPIO14)
TXD0: D1.2 (K), K4.14, R2.2, U4.16 (TXD)
VBAT: C7.2, K3.1 (+), K4.1, K5.12, Q1.3 (D), U3.5 (BAT)
VCC: C3.2, C4.1, D4.4 (VDD), D7.2 (K), K4.2, K5.11, Q1.2 (S), U2.4 (EN), U2.6 (IN)
VUSB: C1.2, C8.2, D5.1 (A), D7.1 (A), F1.1, Q1.1 (G), R3.2, R4.2, R14.2, U1.16 (VCC), U3.4 (VCC), U3.8 (CE)

Notes on the sheet:
Changed: PIN for WS2812B LED IO2 USER BUTTON pin IO0
CH340C USB UART
ESP8266 (ESP12)
PWR LED
WS2812B LED
3.3V voltage regulator
easyC connector
Default pull up & pull down resistors
USB-C connector
User button
Reset
Battery connector
Auto-reset circuit
TP4056M Charger
Header
Automatic source selsction

Board: 2 copper layers, 25.9 x 63.0 mm, 54 parts (2 on the bottom side), 40 nets.

## Commit log

2021-09-23 Syncing to git
2021-09-23 Updating open source files.
